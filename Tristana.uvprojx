# Keil uVision project Tristana.uvprojx, settings and files
target Tristana debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: Tristana.out
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1052DVL6B, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../../../../../CMSIS/Include;../../../../../../devices;..;../../../../../../middleware/lwip/src/apps/httpsrv;../../../..;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../devices/MIMXRT1052/drivers;../../../../../../devices/MIMXRT1052;../../../../../../devices/MIMXRT1052/utilities/io;../../../../../../devices/MIMXRT1052/utilities/str;../../../../../../devices/MIMXRT1052/utilities/log;../../../../../../devices/MIMXRT1052/utilities;../../../../../../devices/MIMXRT1052/xip;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../middleware/lwip/contrib/apps
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
  group board
    board/: fsl_phy.c pin_mux.c
    ./board/: fsl_ft5406_rt.c usr_elcdif.c usr_enet.c usr_qtmr.c usr_sdcard.c emwin_support.c usr_semc.c
  group board/src
    board/src/: board.c clock_config.c
  group CMSIS
    CMSIS/: system_MIMXRT1052.c
  group drivers
    drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_enet.c fsl_gpio.c fsl_lpuart.c
    ./drivers/: fsl_elcdif.c fsl_lpi2c.c fsl_pxp.c fsl_qtmr.c fsl_semc.c fsl_usdhc.c
  group source
    source/: FreeRTOSConfig.h lwipopts.h
    ./source/: main.c http_server.c usr_socket.c AppTask.c bsp_init.c
    ./weather/: weather.c
  group startup
    startup/: startup_MIMXRT1052.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group amazon-freertos/FreeRTOS
    amazon-freertos/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    amazon-freertos/FreeRTOS/portable/: heap_3.c port.c readme.txt
  group amazon-freertos/portable
    amazon-freertos/portable/: fsl_tickless_systick.c
  group lwip
    lwip/: ChangeLogKSDK.txt
  group lwip/doc
    lwip/doc/: contrib.txt mdns.txt mqtt_client.txt NO_SYS_SampleCode.c ppp.txt rawapi.txt savannah.txt sys_arch.txt
  group lwip/doc/doxygen/output
    lwip/doc/doxygen/output/: index.html
  group lwip/port
    lwip/port/: ethernetif.c sys_arch.c
  group lwip/src/api
    lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/apps/httpsrv
    ./lwip/src/apps/httpsrv/: httpsrv.c httpsrv_base64.c httpsrv_fs.c httpsrv_fs_data.c httpsrv_script.c httpsrv_sha1.c httpsrv_supp.c httpsrv_task.c httpsrv_tls.c httpsrv_utf8.c httpsrv_ws.c httpsrv_ws_api.c
  group lwip/src/core
    lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/netif
    lwip/src/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
  group lwip/src/netif/ppp
    lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group emwin/config
    ./emwin/emWin_Config/: GUIConf.h LCDConf.h
  group emwin/lib
    ./emwin/emWin_library/Keil/: emWin_M4F.lib
  group emwin/MainTask
    ./emwin/emWin_MainTask/: EnetActivity.c HomeActivity.c giphy_1.c internet.c SocketActivity.c WeatherActivity.c
  group FATFS/config
    ./fatfs/fatfs_config/: ffconf.h
  group FATFS/source
    ./fatfs/fatfs_source/: diskio.c ff.c ffsystem.c ffunicode.c fsl_sd_disk.c
  group sdmmc/port
    ./sdmmc/port/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group sdmmc/src
    ./sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group cJSON
    ./cJSON/: cJSON.cpp cJSON.h
  group PNG
    ./emwin/png/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
target Tristana flexspi_nor_sdram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: Tristana.out
  AfterMake: C:/keil_v5/ARM/ARMCC/bin/fromelf.exe --bincombined  --output  "$L@L.bin"  "#L"
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FSL_RTOS_FREE_RTOS,SKIP_SYSCLK_INIT,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,CPU_MIMXRT1052DVL6B,
  c misc: as above
  c include: CMSIS;board;board/src;drivers;source;startup;utilities;xip;amazon-freertos/FreeRTOS/portable;amazon-freertos/include;amazon-freertos/portable;lwip/contrib/apps;lwip/port;lwip/port/arch;lwip/src;lwip/src/apps/httpsrv;lwip/src/include;lwip/src/include/lwip;lwip/src/include/lwip/priv;lwip/src/include/lwip/prot;lwip/src/include/netif;lwip/src/include/netif/ppp;lwip/src/include/netif/ppp/polarssl;lwip/src/include/posix;lwip/src/include/posix/sys;emwin/emWin_Config;emwin/emWin_header;emwin/emWin_MainTask;fatfs/fatfs_config;fatfs/fatfs_include;sdmmc/inc;sdmmc/port;.\cJSON;.\weather;.\emwin\png;.\emwin\emWin_MainTask\weather_icon
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: CMSIS;amazon-freertos/FreeRTOS/portable;amazon-freertos/include;amazon-freertos/portable;board;board/src;drivers;lwip/contrib/apps;lwip/port;lwip/port/arch;lwip/src;lwip/src/apps/httpsrv;lwip/src/include;lwip/src/include/lwip;lwip/src/include/lwip/priv;lwip/src/include/lwip/prot;lwip/src/include/netif;lwip/src/include/netif/ppp;lwip/src/include/netif/ppp/polarssl;lwip/src/include/posix;lwip/src/include/posix/sys;source;startup;utilities;xip
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove
target Tristana_Sdram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: Tristana.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1052DVL6B, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FSL_RTOS_FREE_RTOS,SKIP_SYSCLK_INIT,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: as above
  c include: CMSIS;board;board/src;drivers;.\source;startup;utilities;xip;amazon-freertos/FreeRTOS/portable;amazon-freertos/include;amazon-freertos/portable;lwip/contrib/apps;lwip/port;lwip/port/arch;lwip/src;lwip/src/apps/httpsrv;lwip/src/include;lwip/src/include/lwip;lwip/src/include/lwip/priv;lwip/src/include/lwip/prot;lwip/src/include/netif;lwip/src/include/netif/ppp;lwip/src/include/netif/ppp/polarssl;lwip/src/include/posix;lwip/src/include/posix/sys;emwin/emWin_Config;emwin/emWin_header;emwin/MainTask;fatfs/fatfs_config;fatfs/fatfs_include;sdmmc/inc;sdmmc/port
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_ram.scf
  link misc: --remove
